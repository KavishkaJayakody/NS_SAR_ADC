VERSION 5.7 ;
NOWIREEXTENSIONATPIN ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO my_logo
  CLASS BLOCK ;
  ORIGIN 0.000 0.000 ;
  FOREIGN my_logo 0.000 0.000 ;
  SIZE 30.000 BY 12.808 ;
  SYMMETRY X Y R90 ;
  OBS
    LAYER met4 ;
      RECT 0.000 0.000 30.000 12.808 ;
  END
END my_logo

END LIBRARY
